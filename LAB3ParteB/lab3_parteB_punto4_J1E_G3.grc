options:
  parameters:
    author: sebastian_suarez_jeanpaull_valencia_J1E_G3
    copyright: sebastian_suarez_jeanpaull_valencia_J1E_G3
    generate_options: qt_gui
    id: Modulador_SSB
    output_language: python
    title: Modulador_de_SSB
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora (Ac)
    start: '0'
    step: '1e-2'
    stop: '0.5'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud_del_mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilitar signal
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de mensaje
    start: '300'
    step: '100'
    stop: 200e3
    value: 1e3
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente de sensibilidad de amplitud
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/32
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '-Am/2'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: lab3_parteA_Punto1_J1E_G3_0
  id: lab3_parteA_Punto1_J1E_G3
  parameters:
    l_vect: '1024'
  states: {}
- name: lab3_parteB_Punto4y5_J1E_G3_0
  id: lab3_parteB_Punto4y5_J1E_G3
  parameters:
    Ac: Ac
    B: B
    K: K
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"EnvolventeCompleja"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Envolvente compleja"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', lab3_parteB_Punto4y5_J1E_G3_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_real_0, '0', lab3_parteA_Punto1_J1E_G3_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '1']
- [lab3_parteB_Punto4y5_J1E_G3_0, '0', blocks_complex_to_mag_0, '0']
- [lab3_parteB_Punto4y5_J1E_G3_0, '0', blocks_complex_to_real_0, '0']
- [lab3_parteB_Punto4y5_J1E_G3_0, '0', qtgui_freq_sink_x_0, '0']
- [lab3_parteB_Punto4y5_J1E_G3_0, '0', qtgui_time_sink_x_0, '0']
- [lab3_parteB_Punto4y5_J1E_G3_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
